include bsp-image.inc